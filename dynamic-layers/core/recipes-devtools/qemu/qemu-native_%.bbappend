FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "\
 file://0001-qemu-Reinstated-syscall-emulation-through-libc-8.patch \
"
