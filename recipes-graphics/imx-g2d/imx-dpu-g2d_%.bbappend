FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-dpuv2-Select-DPU-render-node-by-driver-name.patch"
