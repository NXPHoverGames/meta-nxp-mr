
PACKAGES =+ " ${PN}-sr150"

FILES:${PN}-sr150 = " \
       ${nonarch_base_libdir}/firmware/nxp/sr150_fw.bin \
"

